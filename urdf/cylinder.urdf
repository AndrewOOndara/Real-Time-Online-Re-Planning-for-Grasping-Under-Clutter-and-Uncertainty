Commit message: update 0.0.1

File: urdf/cylinder.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- removed link box
- added link cylinder; collision cylinder length=1 radius=0.05; visual cylinder length=1 radius=0.05
